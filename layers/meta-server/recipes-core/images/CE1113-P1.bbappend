# Este archivo se ejecuta despues de CE1113-P1.bb
# Añadimos nuestra aplicacion a la imagen

IMAGE_INSTALL:append = " webapp"
