# Este archivo amplía ce1113-p1.bb sin duplicar la imagen principal.
# Añadimos nuestra aplicacion a la imagen

IMAGE_INSTALL:append = " webapp"
