# Habilita la salida analógica integrada de la Raspberry Pi 4.
RPI_EXTRA_CONFIG:append:raspberrypi4 = " \n \
dtparam=audio=on \n \
"
