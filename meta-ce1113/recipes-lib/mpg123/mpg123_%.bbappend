# El backend ALSA es requerido por libaudio para reproducir por el jack.
PACKAGECONFIG:append = " alsa"
