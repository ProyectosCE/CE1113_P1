# libaudio ejecuta mpg123 con salida ALSA para reproducir por el jack físico.
PACKAGECONFIG:append = " alsa"
