SUMMARY = "Aplicaciones de prueba de CE1113"
LICENSE = "MIT"
inherit packagegroup
RDEPENDS:${PN} = " \
    app-operaciones \
    prueba-encoder \
"
