SUMMARY = "API y operaciones compartidas de CE1113"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = "app-operaciones"
