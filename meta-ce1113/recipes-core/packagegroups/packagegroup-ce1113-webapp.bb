SUMMARY = "Servidor HTTP, CGI e interfaz web de CE1113"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = "webapp"
