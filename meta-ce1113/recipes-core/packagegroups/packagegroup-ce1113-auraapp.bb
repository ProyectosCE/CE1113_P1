SUMMARY = "Aplicaciones AuraApp de CE1113"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = " \
    aurabot \
    hola \
"
